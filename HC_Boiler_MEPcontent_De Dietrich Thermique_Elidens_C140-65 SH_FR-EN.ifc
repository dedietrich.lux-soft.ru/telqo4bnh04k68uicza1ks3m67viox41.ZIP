Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-09-30T13:52:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 30 13:52:39 2019 * Host: ddamian-ro-de * Database: C:\Users\DDamian\AppData\Local\Temp\{5EF787B8-7DBB-472F-A4B9-3C96F71624F3}\ifc * Database version: 5507 * Database creation date: Mon Sep 30 13:52:38 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Sep 30 13:52:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 30 13:52:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: C140-65 SH, HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN:C140-65 SH:1294878
In: V00
Type - PredefinedType: WATER; Material: Color RGB 100-100-100, Color RGB 040-040-040, Color RGB 173-175-175, Color RGB 202-154-058, Color RGB 246-246-246, Color RGB 229-190-001, Color RGB 075-186-252, Color RGB 203-040-033
Type - Dimensions - Depth: 1027 mm; Drain Diameter: 22 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 19.05 mm; Height: 1340 mm; Hydronic Return Diameter: 50.8 mm; Hydronic Supply Diameter: 50.8 mm; Supply Air Diameter: 150 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Seasonal Energy Efficiency Etas (%): 94; Voltage: 230 V
Type - Identity Data - Article Description: Floor-standing gas condensing boiler with low-loss header; Article Type: C140-65 SH; Base Family Version: 12.04; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Floor-standing gas condensing boiler with low-loss header; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.04; Manufacturer: De Dietrich Thermique; Manufacturer Art. No.: 7721424; Manufacturer URL: https://www.dedietrich-thermique.fr/; MEPcontent Class: BOILER; Model: C140-65 SH; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: De Dietrich Thermique; Revit Version: 2017; Type Name: C140-65 SH; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 075-186-252; Grey: Color RGB 100-100-100; Light Grey: Color RGB 173-175-175; Red: Color RGB 203-040-033; White: Color RGB 246-246-246; Yellow: Color RGB 229-190-001
Type - Mechanical - Heat Input G20 (GCV): 741633; Heat Input G20 (NCV): 667362; Heat Input G25 (GCV): 741633; Heat Input G25 (NCV): 667362; Heat Input G31 (GCV): 723335; Heat Input G31 (NCV): 667362
Type - Mechanical - Flow - Nominal Water Flow: 0.00073 m3/s
Type - Mechanical - Loads - Maximum Pressure at Nominal Debit (mbar): 4000; Nominal Output (kW): 61.5; Sound Pressure Level dB(A): 40; Unit Weight (kg): 98; Volume: 7.1 m3
Type - Other - Category: Mechanical Equipment; B: 1083 mm; C: 961 mm; D: 400 mm; E: 150 mm; F: 118 mm; Family Name: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN; Flue Gas Inside Diameter: 70 mm; Supply Air Inside Diameter: 115 mm
Type - Text - Pipe Type Category: M561
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich Thermique
Constraints - Offset: 0 mm
Dimensions - Area: 12.2935 m2; Volume: 0.452365 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Hydronic Supply,Hydronic Return,Sanitary,Supply Air,Exhaust Air,Power,Undefined
Mechanical - Flow - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance Safe: 500 mm; Family: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN: C140-65 SH; Family and Type: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN: C140-65 SH; Feet Offset Safe: 40 mm; Front Clearance Safe: 500 mm; Height Helper: 1380 mm; Left Clearance Safe: 500 mm; Legs Visible: yes; Second Leg Offset: 15.4407 mm; Top Clearance Safe: 500 mm; Type: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN: C140-65 SH; Type Id: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 45-65 SH_FR-EN: C140-65 SH; Void Height: 56 mm
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Back Clearance: 500 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Legs Height: 40 mm; Service Space: no; Top Clearance: 500 mm
